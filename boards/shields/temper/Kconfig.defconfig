## boards/shields/temper/Kconfig.defconfig
```kconfig
if SHIELD_TEMPER_RIGHT

config ZMK_KEYBOARD_NAME
    default "Temper Right"

endif
```
